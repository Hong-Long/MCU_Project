# IAR project IAR_STM32F10x_MieHuoRobot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\CMSIS\startup; ..\CMSIS\System; ..; ..\Config; ..\FWLIB\inc; ..\FWLIB\src; ..\User; ..\Project\delay; ..\Project\sys; ..\Project\UART; ..\HardWare\HardConfig; ..\HardWare\LED; ..\HardWare\ov7670; ..\Project\EXTI; ..\HardWare\Computor; ..\HardWare\Motor; ..\Project\Timer; ..\HardWare\ov7725; ..\HardWare\sccb; ..\Project\Voltage
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_STM32F10x_MieHuoRobot.hex
  ILINK.IlinkOutputFile: IAR_STM32F10x_Temple.out
  ILINK.IlinkIcfFile: C:\Users\whl14\Desktop\IAR_MieHuoRobot\Config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group CMSIS/startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS/System
    ../CMSIS/System/: system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HardWare/Computor
    ../HardWare/Computor/: computer.c
  group HardWare/HardConfig
    ../HardWare/HardConfig/: DeviceConfig.c
  group HardWare/LED
    ../HardWare/LED/: led.c
  group HardWare/Motor
    ../HardWare/Motor/: Motor.c
  group HardWare/ov7725
    ../HardWare/ov7725/: ov7725.c
  group HardWare/sccb
    ../HardWare/sccb/: sccb.c
  group Project/delay
    ../Project/delay/: delay.c
  group Project/EXTI
    ../Project/EXTI/: exti.c
  group Project/sys
    ../Project/sys/: sys.c
  group Project/Timer
    ../Project/Timer/: Timer.c
  group Project/UART
    ../Project/UART/: UART.c
  group Project/Voltage
    ../Project/Voltage/: HL_Voltage.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c
