<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <group>
      <name>startup</name>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\startup\startup_stm32f10x_hd.s</name>
      </file>
    </group>
    <group>
      <name>System</name>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\System\system_stm32f10x.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Config</name>
  </group>
  <group>
    <name>FWLIB</name>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FWLIB\src\stm32f10x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>HardWare</name>
    <group>
      <name>Computor</name>
      <file>
        <name>$PROJ_DIR$\..\HardWare\Computor\computer.c</name>
      </file>
    </group>
    <group>
      <name>HardConfig</name>
      <file>
        <name>$PROJ_DIR$\..\HardWare\HardConfig\DeviceConfig.c</name>
      </file>
    </group>
    <group>
      <name>LED</name>
      <file>
        <name>$PROJ_DIR$\..\HardWare\LED\led.c</name>
      </file>
    </group>
    <group>
      <name>Motor</name>
      <file>
        <name>$PROJ_DIR$\..\HardWare\Motor\Motor.c</name>
      </file>
    </group>
    <group>
      <name>ov7725</name>
      <file>
        <name>$PROJ_DIR$\..\HardWare\ov7725\ov7725.c</name>
      </file>
    </group>
    <group>
      <name>sccb</name>
      <file>
        <name>$PROJ_DIR$\..\HardWare\sccb\sccb.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Project</name>
    <group>
      <name>delay</name>
      <file>
        <name>$PROJ_DIR$\..\Project\delay\delay.c</name>
      </file>
    </group>
    <group>
      <name>EXTI</name>
      <file>
        <name>$PROJ_DIR$\..\Project\EXTI\exti.c</name>
      </file>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\Project\sys\sys.c</name>
      </file>
    </group>
    <group>
      <name>Timer</name>
      <file>
        <name>$PROJ_DIR$\..\Project\Timer\Timer.c</name>
      </file>
    </group>
    <group>
      <name>UART</name>
      <file>
        <name>$PROJ_DIR$\..\Project\UART\UART.c</name>
      </file>
    </group>
    <group>
      <name>Voltage</name>
      <file>
        <name>$PROJ_DIR$\..\Project\Voltage\HL_Voltage.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm32f10x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm32f10x_it.c</name>
    </file>
  </group>
</project>


